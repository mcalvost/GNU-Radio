options:
  parameters:
    author: Miguel Calvo Lostal
    generate_options: qt_gui
    id: subbandanalyzer
    output_language: python
    title: CR in 5G FR1 Band
  states: {}

blocks:
- name: Threshold
  id: variable_qtgui_range
  parameters:
    label: Threshold_LOW
    start: '-20'
    step: '0.01'
    stop: '-1'
    value: '-5'
  states: {}
- name: Threshold_0
  id: variable_qtgui_range
  parameters:
    label: Threshold_HIGH
    start: '-20'
    step: '0.01'
    stop: '-1'
    value: '-5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 796e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: mask_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: num
  id: variable
  parameters:
    value: mask_len//num_subbands
  states: {}
- name: num_subbands
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: PowerOOTcpp_Bandcpp_0
  id: PowerOOTcpp_Bandcpp
  parameters:
    fft_len: fft_len
    num_subbands: num_subbands
  states: {}
- name: allocatorcpp_Allocatorcpp_0
  id: allocatorcpp_Allocatorcpp
  parameters:
    mask_len: mask_len
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: fft_len + 1000
    max_iter: num_subbands + 1000
    scale: 1/(4000 + 1000)
    type: float
    vlen: num_subbands
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: num
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: num_subbands*num
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: Threshold_0
    init: '0'
    low: Threshold
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_subbands
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: num_subbands*num
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: plots
  id: qtgui_tab_widget
  parameters:
    gui_hint: (0,0)
    label0: Energy
    label1: Spectrums
    num_tabs: '2'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    color1: '"red"'
    color2: '"blue"'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: plots@1
    label1: TX
    label2: RX
    legend: 'False'
    nconnections: '2'
    type: complex
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: plots@0
    name: '"Thresholded Subbands"'
    vlen: num_subbands*num
    x_axis_label: '"Number of Subbands, after Threshold and Interpolation"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Amplitude"'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: plots@0
    name: '"Power per Subband"'
    vlen: num_subbands
    width1: '2'
    x_axis_label: '"Number of subbands after average"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Relative Gain (dB)"'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_args: buffer_size=100000000
    gain0: '65'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Average
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Average
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}

connections:
- [PowerOOTcpp_Bandcpp_0, '0', blocks_moving_average_xx_0, '0']
- [allocatorcpp_Allocatorcpp_0, '0', fft_vxx_0_0, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_moving_average_xx_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', allocatorcpp_Allocatorcpp_0, '1']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_threshold_ff_0, '0', blocks_repeat_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_threshold_ff_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_vector_to_stream_1, '0', uhd_usrp_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', allocatorcpp_Allocatorcpp_0, '0']
- [fft_vxx_0, '0', PowerOOTcpp_Bandcpp_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_1, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_1, '0']
- [uhd_usrp_source_0, async_msgs, uhd_usrp_source_0, command]
- [virtual_source_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-404-g6f5eb130
